# Keil uVision project STM32H7.uvprojx, settings and files
target STM32H7 (6230000::V6.23::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx, CMSIS_device_header
  c include: ../Core/Inc;../Vendor/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Inc;../Vendor/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Vendor/STM32CubeH7/Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Vendor/STM32CubeH7/Drivers/CMSIS/Include;../Vendor/STM32CubeH7/Drivers/CMSIS/DSP/Include;../User/bsp;../User/Devices/DM_Motor;..\User\Control
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dcmi.c fdcan.c i2c.c octospi.c spi.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../Core/Inc/: stm32h7xx_hal_conf.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Vendor/STM32CubeH7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
    ./RTE/_STM32H7/: RTE_Components.h
    ../Vendor/STM32CubeH7/Drivers/CMSIS/Include/: core_cm7.h
    ../Vendor/STM32CubeH7/Drivers/CMSIS/Device/ST/STM32H7xx/Include/: stm32h723xx.h stm32h7xx.h
  group Bsp
    ../User/bsp/: can_bsp.c led_bsp.c can_bsp.h
  group Device
    ../User/Devices/DM_Motor/: dm_drv.c dm_drv.h
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0
